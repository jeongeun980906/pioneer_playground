Commit message: lidar mesh

File: description/urdf/pioneer3at.urdf (robot description, URDF)
Before this commit: robot pioneer3at, 19 links, 18 joints
Links:
- link lms100: geometry collision box size=0.1 0.1 0.1; visual mesh filename=package://pioneer_playground/description/meshes/lms100.dae
